# IAR project SensorTile.ewp, settings and files
configuration SensorTile (ARM, debug)
  General.OGChipSelectEditMenu: STM32L476JG ST STM32L476JG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L476xx
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32L4xx_HAL_Driver/Inc; ../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32L4xx/Include; ../Drivers/CMSIS/Include; ../Middlewares/ST/STM32_USB_Device_Library/Core/Inc; ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc; ..\BSP\Components\Common; ..\BSP\Components\lsm6dsm; ..\Adafruit_NeoPixel
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: SensorTile.out
  ILINK.IlinkIcfFile: stm32l476xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group AdafruitNeoPixel
    ../Adafruit_NeoPixel/: Adafruit_NeoPixel.c Adafruit_NeoPixel.h
  group Application/EWARM
    ./: startup_stm32l476xx.s
  group Application/User
    ../Src/: dma.c gpio.c main.c spi.c stm32l4xx_hal_msp.c stm32l4xx_it.c usb_device.c usbd_cdc_if.c usbd_conf.c usbd_desc.c
  group BSP
    ../BSP/Components/Common/: accelerometer.h component.h gyroscope.h LSM303AGR_ACC_driver.c LSM303AGR_ACC_driver.h LSM303AGR_ACC_driver_HL.c LSM303AGR_ACC_driver_HL.h LSM303AGR_Combo_driver_HL.h LSM303AGR_MAG_driver.c LSM303AGR_MAG_driver.h LSM303AGR_MAG_driver_HL.c LSM303AGR_MAG_driver_HL.h magnetometer.h sensor.h SensorTile.c SensorTile.h SensorTile_accelero.c SensorTile_accelero.h SensorTile_gyro.c SensorTile_gyro.h
    ../BSP/Components/lsm6dsm/: LSM6DSM_ACC_GYRO_driver.c LSM6DSM_ACC_GYRO_driver.h LSM6DSM_ACC_GYRO_driver_HL.c LSM6DSM_ACC_GYRO_driver_HL.h
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group Drivers/STM32L4xx_HAL_Driver
    ../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_cortex.c stm32l4xx_hal_dma.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_pcd.c stm32l4xx_hal_pcd_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_ll_usb.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
